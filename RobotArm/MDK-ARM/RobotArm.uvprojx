# Keil uVision project RobotArm.uvprojx, settings and files
target RobotArm (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: RobotArm +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c include: ../Core/Inc;                                 ../Drivers/STM32L4xx_HAL_Driver/Inc;                                 ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;                                 ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;                                 ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User/Core
    ../Core/Src/: robotarm.c main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
software components: CMSIS:CORE 4.3.0
