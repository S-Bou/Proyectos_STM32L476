# Keil uVision project NucleoL476GestureDetect.uvprojx, settings and files
target NucleoL476GestureDetect (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: NucleoL476GestureDetect +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,TRACE_UART=0,VL53L0A1_HAVE_UART=1,VL53L0X_LOG_ENABLE,XNUCLEO53L0A1_TRACE=1
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-53L0A1;..\..\..\..\..\..\..\Drivers\BSP\Components\vl53l0x;..\..\..\..\..\..\..\Middlewares\ST\Gestures\GesturesDetect\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Source\Templates
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Application/User
    ../../Src/: stm32l4xx_hal_msp.c stm32l4xx_it.c main.c
  group Application/MDK-ARM
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l476xx.s
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/BSP/vl53l0x
    ../../../../../../../Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform_log.c
  group Drivers/BSP/X-NUCLEO-53L0A1
    ../../../../../../../Drivers/BSP/X-NUCLEO-53L0A1/: uart_trace.c vl53l0a1-x4msp.c vl53l0x_platform.c X-NUCLEO-53L0A1.c
  group Middlewares/GestureDetect
    ../../../../../../../Middlewares/ST/Gestures/GesturesDetect/Src/: ring_buffer.c tof_gestures_DIRSWIPE_1.c tof_gestures_SWIPE_1.c tof_gestures_TAP_1.c tof_motion.c
