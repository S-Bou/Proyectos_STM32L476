# IAR project STM32F401Nucleo.ewp, settings and files
configuration STM32F401Nucleo-VL6180X Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xE ST STM32F401xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; TRACE_UART=1; VL53L0A1_HAVE_UART=1; VL53L0X_LOG_ENABLE; XNUCLEO53L0A1_TRACE=1
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\..\Drivers\BSP\Components\vl53l0x; ..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-53L0A1; ..\..\..\..\..\..\..\Middlewares\ST\Gestures\GesturesDetect\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Inc
  OBJCOPY.OOCOutputFile: STM32F401Nucleo-VL6180X.srec
  ILINK.IlinkOutputFile: STM32F401Nucleo-VL6180X Configuration.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xe.s
  group Application/User
    ../../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/vl53l0x
    ../../../../../../../Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform_log.c
  group Drivers/X-NUCLEO-53L0A1
    ../../../../../../../Drivers/BSP/X-NUCLEO-53L0A1/: uart_trace.c vl53l0a1-x4msp.c vl53l0x_platform.c X-NUCLEO-53L0A1.c
  group Middlewares/GestureDetect
    ../../../../../../../Middlewares/ST/Gestures/GesturesDetect/Src/: ring_buffer.c tof_gestures_DIRSWIPE_1.c tof_gestures_SWIPE_1.c tof_gestures_TAP_1.c tof_motion.c
