# IAR project STM32L476RG-Nucleo.ewp, settings and files
configuration STM32L476RG-Nucleo Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx; TRACE_UART=1; VL53L0A1_HAVE_UART=1; VL53L0X_LOG_ENABLE; XNUCLEO53L0A1_TRACE=1
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-53L0A1; ..\..\..\..\..\..\..\Drivers\BSP\Components\vl53l0x; ..\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Middlewares\ST\Gestures\GesturesDetect\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-6180XA1; ..\..\..\..\..\..\..\Drivers\BSP\Components\vl6180x; ..\..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Include
  OBJCOPY.OOCOutputFile: STM32L476RG-Nucleo.srec
  ILINK.IlinkOutputFile: STM32L476RG-Nucleo Configuration.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l476xx.s
  group Application/User
    ../../Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/GestureDetect
    ../../../../../../../Middlewares/ST/Gestures/GesturesDetect/Src/: ring_buffer.c tof_gestures_DIRSWIPE_1.c tof_gestures_SWIPE_1.c tof_gestures_TAP_1.c tof_motion.c
  group vl53l0x
    ../../../../../../../Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform_log.c
  group X-NUCLEO-53L0A1
    ../../../../../../../Drivers/BSP/X-NUCLEO-53L0A1/: uart_trace.c vl53l0a1-x4msp.c vl53l0x_platform.c X-NUCLEO-53L0A1.c
